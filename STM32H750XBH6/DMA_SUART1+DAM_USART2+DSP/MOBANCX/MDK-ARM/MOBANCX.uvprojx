# Keil uVision project MOBANCX.uvprojx, settings and files
target MOBANCX (6230000::V6.23::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MOBANCX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL,USE_PWR_LDO_SUPPLY
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./HARDWORK;./HARDWORK/CMSIS-DSP;./HARDWORK/CMSIS-DSP/1.16.2;./HARDWORK/CMSIS-DSP/1.16.2/Source;./HARDWORK/CMSIS-DSP/1.16.2/Source/BasicMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/BayesFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/CommonTables;./HARDWORK/CMSIS-DSP/1.16.2/Source/ComplexMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/ControllerFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/DistanceFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/FastMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/FilteringFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/InterpolationFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/MatrixFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/QuaternionMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/StatisticsFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/SupportFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/SVMFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/TransformFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/WindowFunctions;./HARDWORK/CMSIS-DSP/1.16.2/PrivateInclude;./HARDWORK/CMSIS-DSP/1.16.2/Include;./HARDWORK/ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c memorymap.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group ESP8266
    ./HARDWORK/ESP8266/: esp8266.c esp8266.h esp8266_config.h
  group CMSIS-DSP1.16.2
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/BasicMathFunctions/: BasicMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/BayesFunctions/: BayesFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/CommonTables/: CommonTables.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/ControllerFunctions/: ControllerFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/DistanceFunctions/: DistanceFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/FastMathFunctions/: FastMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/FilteringFunctions/: FilteringFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/InterpolationFunctions/: InterpolationFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/MatrixFunctions/: MatrixFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/StatisticsFunctions/: StatisticsFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/SupportFunctions/: SupportFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/SVMFunctions/: SVMFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/TransformFunctions/: TransformFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/WindowFunctions/: WindowFunctions.c
software components: CMSIS:CORE 6.1.0
